do_fetch() {
    :
}
